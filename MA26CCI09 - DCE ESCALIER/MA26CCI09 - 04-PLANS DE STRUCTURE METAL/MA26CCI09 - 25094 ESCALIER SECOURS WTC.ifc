Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0], Option [GridExport:Off], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:Off], Option [LocationBy:0], Option [ViewColors:On], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Tekla.ifc
Time: 2025-07-23T14:41:30
Author: DESKTOP-R0C0PO1\Didier
Organization: Structural Designer
Written by: IFC Parser Version: 3.14.0
Made in: Tekla Structures 2024 Service Pack 4.1, IFC Export Version: 4.0.0.0 Sep 12 2024

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: IPE100 (6)
In: Undefined
Description: IPE100; Material: STEEL/S235JR
Tekla Commun - Nom: BECHE; Profil: IPE100; Matériau: S235JR; Classe: 99; Phase: 1; Repère: 0(?); Repère assemblage: P0(?)
Tekla Quantités - Longueur: 100 mm; Largeur: 55 mm; Hauteur: 100 mm; Surface nette: 0.043 m2; Surface par tonne: 49.471 m2; Surface: 0.001 m2; Volume: 0 m3; Poids: 0.81 kg
BeamBaseQuantities - Longueur: 100 mm; Surface extérieure: 0 m2; Volume net: 0 m3; Poids net: 0.8 kg
Pset_BeamCommon - Inclinaison: 1.5708 rad
Name | Niveau haut | Niveau bas
4 x BECHE | -0.021 | -0.121
2 x BECHE | -0.020 | -0.120

# IfcBeam: IPE80 (8)
In: Undefined
Description: IPE80; Material: STEEL/S235JR
Tekla Commun - Nom: TRAVERSE; Profil: IPE80; Matériau: S235JR; Classe: 1; Phase: 1; Repère: 0(?); Repère assemblage: T0(?)
Tekla Quantités - Longueur: 1429.4 mm; Largeur: 46 mm; Hauteur: 80 mm; Surface nette: 0.473 m2; Surface par tonne: 54.69 m2; Surface: 0.062 m2; Volume: 0.001 m3; Poids: 8.57 kg
BeamBaseQuantities - Longueur: 1429.4 mm; Surface extérieure: 0.5 m2; Volume net: 0 m3; Poids net: 8.2 kg
Pset_BeamCommon - Inclinaison: 0 rad
Name | Niveau haut | Niveau bas
3 x TRAVERSE | +4.360 | +4.280
5 x TRAVERSE | +2.155 | +2.075

# IfcBeam: L50*5 (2)
In: Undefined
Description: L50*5; Material: STEEL/S235JR
Tekla Commun - Nom: CV; Profil: L50*5; Matériau: S235JR; Classe: 1; Phase: 1; Repère: LM0(?); Repère assemblage: LM0(?)
Tekla Quantités - Longueur: 2028.9 mm; Largeur: 50 mm; Hauteur: 50 mm; Surface nette: 0.407 m2; Surface par tonne: 51.486 m2; Surface: 0 m2; Volume: 0.001 m3; Poids: 7.64 kg
BeamBaseQuantities - Longueur: 2028.9 mm; Surface extérieure: 0.3 m2; Volume net: 0 m3; Poids net: 7.6 kg
Pset_BeamCommon - Inclinaison: 0.82902 rad
Name | Niveau haut | Niveau bas
CV | +3.988 | +2.459
CV | +3.951 | +2.422

# IfcBeam: PL4*1500 (27)
In: Undefined
Description: PL4*1500; Material: STEEL/S235JR
Tekla Commun - Nom: MARCHE; Profil: PL4*1500; Matériau: S235JR; Classe: 1; Phase: 1; Repère: 0(?)
Tekla Quantités - Largeur: 4 mm; Hauteur: 1500 mm; Surface: 0.006 m2; Volume: 0.003 m3
BeamBaseQuantities - Volume net: 0 m3
Pset_BeamCommon - Inclinaison: 1.5708 rad
Name | Repère assemblage | Niveau haut | Niveau bas | Tekla Quantités, Longueur (mm) = BeamBaseQuantities, Longueur (mm) | Surface nette (m2) | Surface par tonne (m2) | Poids (kg) | Surface extérieure (m2) | Poids net (kg)
MARCHE | MA0(?) | +4.300 | +4.142 | 453.2 | 1.402 | 64.416 | 21.76 | 1.4 | 21.8
MARCHE | MA0(?) | +4.142 | +3.985 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | MA0(?) | +3.984 | +3.827 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | MA0(?) | +3.827 | +3.670 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | MA0(?) | +3.669 | +3.512 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | MA0(?) | +3.512 | +3.354 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | MA0(?) | +3.354 | +3.197 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | MA0(?) | +3.196 | +3.039 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | MA0(?) | +3.039 | +2.881 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | MA0(?) | +2.881 | +2.724 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | MA0(?) | +2.723 | +2.566 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | MA0(?) | +2.566 | +2.409 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | ATT0(?) | +2.093 | +1.936 | 473 | 1.461 | 64.393 | 22.69 | 1.4 | 22.7
MARCHE | ATT0(?) | +1.936 | +1.779 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | ATT0(?) | +1.778 | +1.621 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | ATT0(?) | +1.621 | +1.464 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | ATT0(?) | +1.463 | +1.306 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | ATT0(?) | +1.306 | +1.149 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | ATT0(?) | +1.148 | +0.991 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | ATT0(?) | +0.991 | +0.834 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | ATT0(?) | +0.833 | +0.676 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | ATT0(?) | +0.676 | +0.519 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | ATT0(?) | +0.518 | +0.361 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | MA0(?) | +2.408 | +2.195 | 559.2 | 1.72 | 64.313 | 26.75 | 1.8 | 26.8
MARCHE | MA0(?) | +2.251 | +2.094 | 563.3 | 1.733 | 64.309 | 26.95 | 1.8 | 26.9
MARCHE | ATT0(?) | +0.361 | +0.204 | 503.2 | 1.552 | 64.362 | 24.11 | 1.6 | 24.1
MARCHE | MA0(?) | +0.203 | -0.004 | 561.6 | 1.729 | 64.31 | 26.89 | 1.8 | 26.9

# IfcBeam: TUBE-26.9*2 (27)
In: Undefined
Description: TUBE-26.9*2; Material: STEEL/S235JR
Tekla Commun - Profil: TUBE-26.9*2; Matériau: S235JR; Phase: 1
Tekla Quantités - Hauteur: 26.9 mm; Surface: 0 m2
BeamBaseQuantities - Volume net: 0 m3
Name | Nom | Classe | Repère | Repère assemblage | Niveau haut | Niveau bas | Tekla Quantités, Longueur (mm) = BeamBaseQuantities, Longueur (mm) | Largeur (mm) | Surface nette (m2) | Surface par tonne (m2) | Volume (m3) | Poids (kg) | Surface extérieure (m2) | Poids net (kg) | Inclinaison (rad)
LISSE | LISSE | 99 | E0(?) | E0(?) | +2.315 | +2.229 | 387.1 | 2 | 0.033 | 68.366 | 0 | 0.48 | 0 | 0.5 | 0.41258
LISSE | LISSE | 99 | E0(?) | E0(?) | +2.690 | +2.600 | 393.9 | 2 | 0.033 | 68.361 | 0 | 0.48 | 0 | 0.5 | 0.43166
LISSE | LISSE | 99 | E0(?) | E0(?) | +2.916 | +2.815 | 398.7 | 2 | 0.033 | 68.357 | 0 | 0.49 | 0 | 0.5 | 0.49218
RAIL | RAIL | 1 | 0(?) | 0(?) | +2.279 | +2.252 | 1328.5 | 26.9 | 0.111 | 68.126 | 0 | 1.63 | 0.1 | 1.6 | 0
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | 0(?) | +2.636 | +2.609 | 1318.5 | 26.9 | 0.11 | 68.126 | 0 | 1.62 | 0.1 | 1.5 | 0
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | 0(?) | +2.831 | +2.804 | 1318.5 | 26.9 | 0.11 | 68.126 | 0 | 1.62 | 0.1 | 1.5 | 0
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | 0(?) | +3.026 | +2.999 | 1318.5 | 26.9 | 0.11 | 68.126 | 0 | 1.62 | 0.1 | 1.5 | 0
RAIL | RAIL | 1 | 0(?) | 0(?) | +4.484 | +4.457 | 335.8 | 26.9 | 0.028 | 68.418 | 0 | 0.41 | 0 | 0.5 | 0.00145
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | 0(?) | +4.842 | +4.814 | 325.8 | 26.9 | 0.026 | 68.43 | 0 | 0.4 | 0 | 0.5 | 0.00296
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | 0(?) | +5.037 | +5.009 | 325.8 | 26.9 | 0.026 | 68.43 | 0 | 0.4 | 0 | 0.5 | 0.00296
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | 0(?) | +5.232 | +5.204 | 325.8 | 26.9 | 0.026 | 68.43 | 0 | 0.4 | 0 | 0.5 | 0.00296
RAIL | RAIL | 1 | 0(?) | 0(?) | +2.279 | +2.252 | 1330 | 26.9 | 0.111 | 68.126 | 0 | 1.63 | 0.1 | 1.6 | 0
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | 0(?) | +2.636 | +2.609 | 1320 | 26.9 | 0.11 | 68.126 | 0 | 1.62 | 0.1 | 1.5 | 0
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | 0(?) | +2.831 | +2.804 | 1320 | 26.9 | 0.11 | 68.126 | 0 | 1.62 | 0.1 | 1.5 | 0
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | 0(?) | +3.026 | +2.999 | 1320 | 26.9 | 0.11 | 68.126 | 0 | 1.62 | 0.1 | 1.5 | 0
RAIL | RAIL | 1 | 0(?) | M0(?) | +4.484 | +4.457 | 1930.9 | 26.9 | 0.161 | 68.095 | 0 | 2.37 | 0.2 | 2.3 | 0
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | M0(?) | +4.841 | +4.814 | 1920.9 | 26.9 | 0.161 | 68.095 | 0 | 2.36 | 0.2 | 2.3 | 0
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | M0(?) | +5.036 | +5.009 | 1920.9 | 26.9 | 0.161 | 68.095 | 0 | 2.36 | 0.2 | 2.3 | 0
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | M0(?) | +5.231 | +5.204 | 1920.9 | 26.9 | 0.161 | 68.095 | 0 | 2.36 | 0.2 | 2.3 | 0
RAIL | RAIL | 1 | 0(?) | M0(?) | +4.484 | +4.457 | 1453.6 | 26.9 | 0.122 | 68.117 | 0 | 1.79 | 0.1 | 1.7 | 0
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | M0(?) | +4.841 | +4.814 | 1443.6 | 26.9 | 0.121 | 68.117 | 0 | 1.77 | 0.1 | 1.7 | 0
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | M0(?) | +5.036 | +5.009 | 1443.6 | 26.9 | 0.121 | 68.117 | 0 | 1.77 | 0.1 | 1.7 | 0
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | M0(?) | +5.231 | +5.204 | 1443.6 | 26.9 | 0.121 | 68.117 | 0 | 1.77 | 0.1 | 1.7 | 0
RAIL | RAIL | 1 | 0(?) | 0(?) | +2.279 | +2.252 | 3250 | 26.9 | 0.272 | 68.067 | 0.001 | 3.99 | 0.3 | 3.8 | 0
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | 0(?) | +2.636 | +2.609 | 3240 | 26.9 | 0.271 | 68.067 | 0.001 | 3.98 | 0.3 | 3.8 | 0
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | 0(?) | +2.831 | +2.804 | 3240 | 26.9 | 0.271 | 68.067 | 0.001 | 3.98 | 0.3 | 3.8 | 0
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 1 | 0(?) | 0(?) | +3.026 | +2.999 | 3240 | 26.9 | 0.271 | 68.067 | 0.001 | 3.98 | 0.3 | 3.8 | 0

# IfcBeam: TUBE-48.3*2 (17)
In: Undefined
Description: TUBE-48.3*2; Material: STEEL/S235JR
Tekla Commun - Profil: TUBE-48.3*2; Matériau: S235JR; Phase: 1; Repère: 0(?)
Tekla Quantités - Hauteur: 48.3 mm; Surface: 0 m2
BeamBaseQuantities - Volume net: 0 m3
Name | Nom | Classe | Repère assemblage | Niveau haut | Niveau bas | Tekla Quantités, Longueur (mm) = BeamBaseQuantities, Longueur (mm) | Largeur (mm) | Surface nette (m2) | Surface par tonne (m2) | Volume (m3) | Poids (kg) | Surface extérieure (m2) | Poids net (kg) | Inclinaison (rad)
2 x COUDE | COUDE | 99 | 0(?) | +3.222 | +3.174 | 78.5 | 2 | 0.012 | 66.838 | 0 | 0.18 | 0 | 0.2 | 0.00001
COUDE | COUDE | 99 | 0(?) | +3.222 | +3.171 | 24.8 | 2 | 0.004 | 70.757 | 0 | 0.06 | 0 | 0.1 | 0.2481
RAIL | RAIL | 1 | 0(?) | +3.222 | +3.174 | 1307.2 | 48.3 | 0.196 | 65.786 | 0 | 2.99 | 0.2 | 2.9 | 0
COUDE | COUDE | 99 | 0(?) | +3.225 | +3.174 | 24.9 | 2 | 0.004 | 70.74 | 0 | 0.06 | 0 | 0.1 | 0.24892
COUDE | COUDE | 99 | M0(?) | +5.427 | +5.376 | 24.9 | 2 | 0.004 | 70.74 | 0 | 0.06 | 0 | 0.1 | 0.24892
COUDE | COUDE | 99 | M0(?) | +5.427 | +5.379 | 78.5 | 2 | 0.012 | 66.838 | 0 | 0.18 | 0 | 0.2 | 0.00005
RAIL | RAIL | 1 | 0(?) | +5.427 | +5.379 | 145 | 48.3 | 0.022 | 66.564 | 0 | 0.33 | 0 | 0.3 | 0.00007
RAIL | RAIL | 1 | 0(?) | +5.427 | +5.379 | 371.3 | 48.3 | 0.056 | 66.031 | 0 | 0.85 | 0.1 | 0.8 | 0.00003
RAIL | RAIL | 1 | 0(?) | +3.222 | +3.174 | 1676.9 | 48.3 | 0.252 | 65.765 | 0 | 3.83 | 0.3 | 3.7 | 0
LISSE | LISSE | 99 | M0(?) | +3.122 | +3.073 | 180.3 | 48.3 | 0.043 | 105.099 | 0 | 0.41 | 0 | 0.6 | 0
RAIL | RAIL | 1 | M0(?) | +5.427 | +5.379 | 145 | 48.3 | 0.022 | 66.564 | 0 | 0.33 | 0 | 0.3 | 0
RAIL | RAIL | 1 | M0(?) | +5.427 | +5.379 | 1950.9 | 48.3 | 0.293 | 65.754 | 0.001 | 4.46 | 0.3 | 4.3 | 0
RAIL | RAIL | 1 | M0(?) | +5.427 | +5.379 | 1280.1 | 48.3 | 0.192 | 65.788 | 0 | 2.92 | 0.2 | 2.8 | 0
RAIL | RAIL | 1 | 0(?) | +3.222 | +3.174 | 3270 | 48.3 | 0.491 | 65.728 | 0.001 | 7.47 | 0.5 | 7.1 | 0
RAIL | RAIL | 1 | M0(?) | +1.105 | +0.531 | 1331.8 | 48.3 | 0.2 | 65.696 | 0 | 3.04 | 0.2 | 2.9 | 0
RAIL | RAIL | 1 | 0(?) | +1.105 | +0.531 | 1331.8 | 48.3 | 0.2 | 65.696 | 0 | 3.04 | 0.2 | 2.9 | 0

# IfcBeam: TUBE-76.1*2.9 (5)
In: Undefined
Description: TUBE-76.1*2.9; Material: STEEL/S235JR
Tekla Commun - Nom: TRAVERSE; Profil: TUBE-76.1*2.9; Matériau: S235JR; Classe: 1; Phase: 1; Repère: 0(?); Repère assemblage: T0(?)
Tekla Quantités - Largeur: 76.1 mm; Hauteur: 76.1 mm; Surface: 0 m2
BeamBaseQuantities - Volume net: 0 m3
Pset_BeamCommon - Inclinaison: 0 rad
Name | Niveau haut | Niveau bas | Tekla Quantités, Longueur (mm) = BeamBaseQuantities, Longueur (mm) | Surface nette (m2) | Surface par tonne (m2) | Volume (m3) | Poids (kg) | Surface extérieure (m2) | Poids net (kg)
2 x TRAVERSE | +1.491 | +1.415 | 1161.4 | 0.277 | 45.486 | 0.001 | 6.08 | 0.3 | 5.9
TRAVERSE | +2.356 | +2.280 | 1279.1 | 0.305 | 45.475 | 0.001 | 6.7 | 0.3 | 6.5
TRAVERSE | +1.491 | +1.415 | 3069.1 | 0.73 | 45.417 | 0.002 | 16.07 | 0.7 | 15.7
TRAVERSE | +1.491 | +1.415 | 3220.3 | 0.766 | 45.415 | 0.002 | 16.86 | 0.7 | 16.4

# IfcBeam: UPE240 (14)
In: Undefined
Description: UPE240; Material: STEEL/S235JR
Tekla Commun - Profil: UPE240; Matériau: S235JR; Classe: 1; Phase: 1; Repère: 0(?)
Tekla Quantités - Largeur: 90 mm; Hauteur: 240 mm; Surface par tonne: 26.9 m2
BeamBaseQuantities - Volume net: 0 m3
Name | Nom | Repère assemblage | Niveau haut | Niveau bas | Tekla Quantités, Longueur (mm) = BeamBaseQuantities, Longueur (mm) | Surface nette (m2) | Surface (m2) | Volume (m3) | Poids (kg) | Surface extérieure (m2) | Poids net (kg) | Inclinaison (rad)
TRAVERSE | TRAVERSE | T0(?) | +4.360 | +4.120 | 1346.4 | 1.12 | 0.121 | 0.005 | 40.69 | 1.1 | 39.7 | 0
TRAVERSE | TRAVERSE | T0(?) | +4.360 | +4.120 | 399.1 | 0.337 | 0.036 | 0.002 | 12.06 | 0.3 | 11.8 | 0.00001
2 x TRAVERSE | TRAVERSE | T0(?) | +4.360 | +4.120 | 1563.6 | 1.274 | 0.141 | 0.006 | 47.26 | 1.3 | 45.2 | 0
TRAVERSE | TRAVERSE | T0(?) | +4.360 | +4.120 | 1476.4 | 1.227 | 0.133 | 0.006 | 44.62 | 1.3 | 43.5 | 0
TRAVERSE | TRAVERSE | T0(?) | +4.360 | +4.120 | 2090.9 | 1.735 | 0.188 | 0.008 | 63.19 | 1.8 | 61.6 | 0
Unnamed |  | 0(?) | +2.185 | +1.945 | 61.4 | 0.033 | 0 | 0 | 1.86 | 0 | 0.8 | 0
2 x Unnamed |  | LM0(?) | +2.185 | +1.945 | 76.4 | 0.046 | 0.007 | 0 | 2.31 | 0.1 | 1.5 | 0.00001
Unnamed |  | LM0(?) | +2.185 | +1.945 | 61.4 | 0.033 | 0 | 0 | 1.86 | 0 | 0.8 | 0.00007
2 x TRAVERSE | TRAVERSE | T0(?) | +2.155 | +1.915 | 1336.4 | 1.111 | 0.12 | 0.005 | 40.39 | 1.1 | 39.4 | 0
2 x TRAVERSE | TRAVERSE | T0(?) | +2.155 | +1.915 | 3450 | 2.857 | 0.311 | 0.013 | 104.27 | 2.8 | 101.7 | 0

# IfcColumn: ECROU_M20 (36)
In: Undefined
Description: ECROU_M20; Material: STEEL/S235JR
Tekla Commun - Nom: ECROU; Profil: ECROU_M20; Matériau: S235JR; Classe: 1; Phase: 1; Repère: 0(?); Repère assemblage: B0(?)
Tekla Quantités - Longueur: 20 mm; Largeur: 34.6 mm; Hauteur: 30 mm; Surface nette: 0.004 m2; Surface par tonne: 29.724 m2; Surface: 0.001 m2; Volume: 0 m3; Poids: 0.12 kg
ColumnBaseQuantities - Longueur: 20 mm; Surface extérieure: 0 m2; Volume net: 0 m3; Poids net: 0.1 kg
Pset_ColumnCommon - Inclinaison: 1.5708 rad
Name | Niveau haut | Niveau bas
8 x ECROU | +0.011 | -0.009
8 x ECROU | -0.289 | -0.309
8 x ECROU | -0.319 | -0.339
4 x ECROU | +0.012 | -0.008
4 x ECROU | -0.288 | -0.308
4 x ECROU | -0.318 | -0.338

# IfcColumn: HEA100 (6)
In: Undefined
Description: HEA100; Material: STEEL/S235JR
Tekla Commun - Profil: HEA100; Matériau: S235JR; Classe: 1; Phase: 1; Repère: 0(?); Repère assemblage: P0(?)
Tekla Quantités - Longueur: 41.2 mm; Largeur: 100 mm; Hauteur: 96 mm; Surface nette: 0.028 m2; Surface par tonne: 33.646 m2; Surface: 0.002 m2; Volume: 0 m3; Poids: 0.69 kg
ColumnBaseQuantities - Longueur: 41.2 mm; Surface extérieure: 0 m2; Volume net: 0 m3; Poids net: 0.6 kg
Pset_ColumnCommon - Inclinaison: 1.5708 rad
Name | Niveau haut | Niveau bas
2 x Unnamed | +4.108 | +4.067
4 x Unnamed | +1.903 | +1.862

# IfcColumn: TF-M20 (12)
In: Undefined
Description: TF-M20; Material: MISCELLANEOUS/8.8
Tekla Commun - Nom: BARRE; Profil: TF-M20; Matériau: 8.8; Classe: 1; Phase: 1; Repère: 0(?); Repère assemblage: B0(?)
Tekla Quantités - Longueur: 400 mm; Largeur: 20 mm; Hauteur: 20 mm; Surface nette: 0.025 m2; Surface par tonne: 28.529 m2; Surface: 0 m2; Volume: 0 m3; Poids: 0.87 kg
ColumnBaseQuantities - Longueur: 400 mm; Surface extérieure: 0 m2; Volume net: 0 m3; Poids net: 0.8 kg
Pset_ColumnCommon - Inclinaison: 1.5708 rad
Name | Niveau haut | Niveau bas
8 x BARRE | +0.041 | -0.359
4 x BARRE | +0.042 | -0.358

# IfcColumn: TUBE-139.7*4 (6)
In: Undefined
Description: TUBE-139.7*4; Material: STEEL/S235JR
Tekla Commun - Nom: POTEAU; Profil: TUBE-139.7*4; Matériau: S235JR; Classe: 1; Phase: 1; Repère: 0(?); Repère assemblage: P0(?)
Tekla Quantités - Largeur: 139.7 mm; Hauteur: 139.7 mm; Surface: 0.002 m2
ColumnBaseQuantities - Volume net: 0 m3
Pset_ColumnCommon - Inclinaison: 1.5708 rad
Name | Niveau haut | Niveau bas | Tekla Quantités, Longueur (mm) = ColumnBaseQuantities, Longueur (mm) | Surface nette (m2) | Surface par tonne (m2) | Volume (m3) | Poids (kg) | Surface extérieure (m2) | Poids net (kg)
2 x POTEAU | +4.057 | -0.008 | 4065 | 1.779 | 32.685 | 0.007 | 54.42 | 1.8 | 53.5
4 x POTEAU | +1.852 | -0.009 | 1860.6 | 0.815 | 32.721 | 0.003 | 24.91 | 0.7 | 24.5

# IfcElementAssembly (125)
In: Undefined
Name | Repère Assemblage/Elément béton | Position maillage Assemblage/Elément béton | Niveau Haut Assemblage/Elément béton | Niveau Bas Assemblage/Elément béton | Poids Assemblage/Elément béton (kg) | Largeur (mm)
LIMON | LM0(?) | 3/B-C | +2.185 | +0.025 | 132 | 90
PLATINE | E0(?) | 4/C | +2.193 | +2.185 | 0.7 | 8
MONTANT GARDE-CORPS | M0(?) | 4/C | +3.075 | +2.193 | 4 | 10
MONTANT GARDE-CORPS | M0(?) | 4/C | +3.132 | +2.193 | 4.3 | 10
RAIL | 0(?) | 4/C-D | +5.427 | +0.168 | 185.4 | 5258.8
LISSE | E0(?) | 2-3/C | +2.315 | +2.229 | 0.5 | 45.1
LISSE | E0(?) | 2-3/C | +2.690 | +2.600 | 0.5 | 45.8
LISSE | E0(?) | 2-3/C | +2.916 | +2.815 | 0.5 | 48.1
RAIL | 0(?) | 4/C-D | +2.279 | +2.252 | 1.6 | 26.9
MONTANT GARDE-CORPS | 0(?) | 4/C-D | +2.636 | +2.609 | 1.6 | 26.9
MONTANT GARDE-CORPS | 0(?) | 4/C-D | +2.831 | +2.804 | 1.6 | 26.9
MONTANT GARDE-CORPS | 0(?) | 4/C-D | +3.026 | +2.999 | 1.6 | 26.9
MONTANT GARDE-CORPS | M0(?) | 4/D | +3.174 | +2.155 | 5.1 | 120
MONTANT GARDE-CORPS | M0(?) | 4/C-D | +3.174 | +2.155 | 5.1 | 120
MONTANT GARDE-CORPS | M0(?) | 3/B | +5.427 | +0.168 | 154.1 | 5686.7
MONTANT GARDE-CORPS | M0(?) | 1/B | +5.248 | +4.360 | 4.4 | 120
LIMON | LM0(?) | 4/B-C | +2.185 | +0.025 | 132 | 90
TRAVERSE | T0(?) | 1/A-B | +4.360 | +4.280 | 9.7 | 110
2 x TRAVERSE | T0(?) | 1-2/A-B | +4.360 | +4.280 | 9.7 | 110
TRAVERSE | T0(?) | 1/A-B | +4.360 | +4.120 | 43.9 | 90
TRAVERSE | T0(?) | 1/B | +4.360 | +4.120 | 15.7 | 200
TOLE | E0(?) | 1/B | +4.355 | +4.125 | 3.6 | 10
CAILLEBOTIS | G0(?) | 1-2/A-B | +4.390 | +4.360 | 402 | 30
CAILLEBOTIS | G0(?) | 1-2/A-B | +4.390 | +4.360 | 365 | 30
2 x CAILLEBOTIS | G0(?) | 3-4/C-D | +2.185 | +2.155 | 316.7 | 30
2 x CAILLEBOTIS | G0(?) | 1-2/C-D | +2.185 | +2.155 | 316.7 | 30
POTEAU | P0(?) | 1/D | +1.913 | -0.121 | 33.5 | 270.5
BARRE | B0(?) | 1/D | +0.041 | -0.359 | 3.5 | 280
POTEAU | P0(?) | 1/C | +1.913 | -0.121 | 33.8 | 270.5
BARRE | B0(?) | 1/C | +0.041 | -0.359 | 3.5 | 280
POTEAU | P0(?) | 4/D | +1.913 | -0.121 | 33.5 | 270.5
BARRE | B0(?) | 4/D | +0.041 | -0.359 | 3.5 | 280
POTEAU | P0(?) | 4/C | +1.913 | -0.121 | 33.8 | 270.5
BARRE | B0(?) | 4/C | +0.041 | -0.359 | 3.5 | 280
POTEAU | P0(?) | 2/A | +4.118 | -0.120 | 64.1 | 270
BARRE | B0(?) | 2/A | +0.042 | -0.358 | 3.5 | 280
BARRE | B0(?) | 1/A | +0.042 | -0.358 | 3.5 | 280
POTEAU | P0(?) | 1/A | +4.118 | -0.120 | 64.1 | 270
CV | LM0(?) | 1-2/A | +3.988 | +2.459 | 7.6 | 50
TRAVERSE | T0(?) | 1-2/A | +2.356 | +2.280 | 8 | 76.1
CV | LM0(?) | 1-2/A | +3.951 | +2.422 | 7.6 | 50
TRAVERSE | T0(?) | 1-4/C | +1.611 | +1.415 | 22.6 | 76.1
CV | CV0(?) | 3-4/C | +1.903 | +1.503 | 1.6 | 45
TRAVERSE | T0(?) | 1-4/C | +2.155 | +1.800 | 112.2 | 90
CV | CV0(?) | 3-4/C | +1.903 | +1.503 | 1.9 | 45
CV | CV0(?) | 3/C | +1.903 | +1.503 | 1.9 | 45
CV | CV0(?) | 2/C | +1.903 | +1.503 | 1.8 | 45
CV | CV0(?) | 1-2/C | +1.903 | +1.503 | 1.8 | 45
CV | CV0(?) | 1-2/C | +1.903 | +1.503 | 1.6 | 45
CV | CV0(?) | 3-4/D | +1.903 | +1.503 | 1.9 | 45
CV | CV0(?) | 3/D | +1.903 | +1.503 | 1.9 | 45
TRAVERSE | T0(?) | 1-4/D | +2.155 | +1.800 | 112.2 | 90
CV | CV0(?) | 2/D | +1.903 | +1.503 | 1.8 | 45
CV | CV0(?) | 1-2/D | +1.903 | +1.503 | 1.8 | 45
CV | CV0(?) | 3-4/D | +1.903 | +1.503 | 1.6 | 45
TRAVERSE | T0(?) | 1-4/D | +1.611 | +1.415 | 22 | 76.1
CV | CV0(?) | 1-2/D | +1.903 | +1.503 | 1.6 | 45
2 x CV | CV0(?) | 1/C-D | +1.903 | +1.503 | 1.9 | 45
TRAVERSE | T0(?) | 1/C-D | +2.155 | +1.809 | 46.6 | 90
TRAVERSE | T0(?) | 1/C-D | +1.597 | +1.415 | 8.6 | 76.1
2 x CV | CV0(?) | 4/C-D | +1.903 | +1.503 | 1.9 | 45
TRAVERSE | T0(?) | 4/C-D | +1.597 | +1.415 | 8.6 | 76.1
TRAVERSE | T0(?) | 4/C-D | +2.155 | +1.809 | 46.6 | 100
 | 0(?) | 2/C | +2.185 | +1.945 | 3.5 | 90
LIMON | LM0(?) | 1/B-C | +4.360 | +1.945 | 143 | 90
MARCHE | MA0(?) | 1-2/C | +2.251 | +2.094 | 29.8 | 404.1
TRAVERSE | T0(?) | 1-2/A | +4.360 | +4.120 | 64.8 | 90
LIMON | LM0(?) | 2/B-C | +4.360 | +1.945 | 139.5 | 90
MARCHE | MA0(?) | 1-2/B-C | +2.408 | +2.195 | 29.3 | 344
MARCHE | MA0(?) | 1-2/B-C | +2.566 | +2.409 | 26.6 | 344
MARCHE | MA0(?) | 1-2/B-C | +2.881 | +2.724 | 26.6 | 344
MARCHE | MA0(?) | 1-2/B-C | +3.039 | +2.881 | 26.6 | 344
MARCHE | MA0(?) | 1-2/B-C | +3.196 | +3.039 | 26.6 | 344
MARCHE | MA0(?) | 1-2/B-C | +3.354 | +3.197 | 26.6 | 344
MARCHE | MA0(?) | 1-2/B-C | +3.512 | +3.354 | 26.6 | 344
MARCHE | MA0(?) | 1-2/B | +4.142 | +3.985 | 26.6 | 344
MARCHE | MA0(?) | 1-2/B-C | +3.984 | +3.827 | 26.6 | 344
MARCHE | MA0(?) | 1-2/B-C | +3.827 | +3.670 | 26.6 | 344
MARCHE | MA0(?) | 1-2/B-C | +3.669 | +3.512 | 26.6 | 344
MARCHE | MA0(?) | 1-2/B | +4.300 | +4.142 | 23.1 | 344
ATTACHE MARCHE | ATT0(?) | 3-4/C | +2.093 | +1.894 | 25.4 | 313.9
ATTACHE MARCHE | ATT0(?) | 3-4/B-C | +1.936 | +1.737 | 26.9 | 344
ATTACHE MARCHE | ATT0(?) | 3-4/B-C | +1.778 | +1.579 | 26.9 | 344
ATTACHE MARCHE | ATT0(?) | 3-4/B-C | +1.621 | +1.422 | 26.9 | 344
ATTACHE MARCHE | ATT0(?) | 3-4/B-C | +1.463 | +1.264 | 26.9 | 344
ATTACHE MARCHE | ATT0(?) | 3-4/B-C | +1.306 | +1.107 | 26.9 | 344
ATTACHE MARCHE | ATT0(?) | 3-4/B-C | +1.148 | +0.949 | 26.9 | 344
ATTACHE MARCHE | ATT0(?) | 3-4/B-C | +0.991 | +0.792 | 26.9 | 344
ATTACHE MARCHE | ATT0(?) | 3-4/B-C | +0.833 | +0.634 | 26.9 | 344
ATTACHE MARCHE | ATT0(?) | 3-4/B-C | +0.676 | +0.477 | 26.9 | 344
ATTACHE MARCHE | ATT0(?) | 3-4/B-C | +0.518 | +0.319 | 26.9 | 344
ATTACHE MARCHE | ATT0(?) | 3-4/B | +0.361 | +0.162 | 26.9 | 344
 | E0(?) | 3/B | -0.011 | -0.021 | 1.9 | 10
 | E0(?) | 4/B | -0.011 | -0.021 | 1.9 | 10
LIMON | LM0(?) | 3/B | +0.168 | -0.011 | 5.4 | 90
LIMON | LM0(?) | 4/B | +0.168 | -0.011 | 5.4 | 90
ATTACHE MARCHE | ATT0(?) | 1-2/B | +4.223 | +4.101 | 0.2 | 5
ATTACHE MARCHE | ATT0(?) | 1-2/B | +4.065 | +3.943 | 0.2 | 5
ATTACHE MARCHE | ATT0(?) | 1-2/B-C | +3.908 | +3.786 | 0.2 | 5
ATTACHE MARCHE | ATT0(?) | 1-2/B-C | +3.750 | +3.628 | 0.2 | 5
ATTACHE MARCHE | ATT0(?) | 1-2/B-C | +3.592 | +3.470 | 0.2 | 5
ATTACHE MARCHE | ATT0(?) | 1-2/B-C | +3.435 | +3.313 | 0.2 | 5
ATTACHE MARCHE | ATT0(?) | 1-2/B-C | +3.277 | +3.155 | 0.2 | 5
ATTACHE MARCHE | ATT0(?) | 1-2/B-C | +3.119 | +2.997 | 0.2 | 5
ATTACHE MARCHE | ATT0(?) | 1-2/B-C | +2.962 | +2.840 | 0.2 | 5
ATTACHE MARCHE | ATT0(?) | 1-2/B-C | +2.804 | +2.682 | 0.2 | 5
ATTACHE MARCHE | ATT0(?) | 1-2/B-C | +2.647 | +2.524 | 0.2 | 5
MARCHE | MA0(?) | 1-2/B-C | +2.723 | +2.566 | 26.6 | 344
ATTACHE MARCHE | ATT0(?) | 1-2/B-C | +2.489 | +2.367 | 0.2 | 5
TRAVERSE | T0(?) | 1-2/B | +4.360 | +4.120 | 47.9 | 90
TRAVERSE | T0(?) | 1/A-B | +4.360 | +4.120 | 48.9 | 90
TRAVERSE | T0(?) | 2/A-B | +4.360 | +4.120 | 48.9 | 90
ATTACHE MARCHE | ATT0(?) | 1-2/C | +2.331 | +2.209 | 0.2 | 5
TRAVERSE | T0(?) | 4/C-D | +2.155 | +2.075 | 9.7 | 110
TRAVERSE | T0(?) | 3-4/C-D | +2.155 | +2.075 | 9.7 | 110
TRAVERSE | T0(?) | 3/C-D | +2.155 | +2.075 | 9.7 | 110
TRAVERSE | T0(?) | 1/C-D | +2.155 | +2.075 | 9.7 | 110
TRAVERSE | T0(?) | 1-2/C-D | +2.155 | +2.075 | 9.7 | 110
ATTACHE MARCHE | ATT0(?) | 3-4/B | +0.127 | -0.020 | 0.5 | 55
MARCHE | MA0(?) | 3-4/B | +0.203 | -0.004 | 29.4 | 344

# IfcMechanicalFastener: Bolt assembly (328)
In: Undefined
Tekla Boulons - Lieu de booulonnage: Montage; Trou oblong X: 0 mm; Trou oblong Y: 0 mm
Name | NominalDiameter (mm) = Diamètre rondelle (mm) | NominalLength (mm) = Longueur (mm) | Material | Nom | Standard | Diamètre (mm) | Quantité | Diamètre du trou (mm) | Nom écrou | Type écrou | Quantité d'écrou | Nom rondelle | Type rondelle | Quantité de rondelle
50 x Bolt assembly | 12 | 35 | SB8.8 Galva | M12*35 | SB8.8_GALVA | 12 | 1 | 15 | ECROU-M12-E-SB8.8 | E-SB8.8 | 1 | RONDELLE-M12-PLA-8.8 | PLA-8.8 | 0
Bolt assembly | 12 | 100 | SB8.8 Galva | M12*100 | SB8.8_GALVA | 12 | 1 | 14 | ECROU-M12-E-SB8.8 | E-SB8.8 | 1 | RONDELLE-M12-PLA-8.8 | PLA-8.8 | 1
2 x Bolt assembly | 12 | 40 | SB8.8 Galva | M12*40 | SB8.8_GALVA | 12 | 1 | 14 | ECROU-M12-E-SB8.8 | E-SB8.8 | 1 | RONDELLE-M12-PLA-8.8 | PLA-8.8 | 1
34 x Bolt assembly | 12 | 40 | SB8.8 Galva | M12*40 | SB8.8_GALVA | 12 | 2 | 14 | ECROU-M12-E-SB8.8 | E-SB8.8 | 2 | RONDELLE-M12-PLA-8.8 | PLA-8.8 | 2
Bolt assembly | 12 | 40 | 8.8 | M12*40 | 8.8 | 12 | 2 | 14 | ECROU-M12-E-8.8 | E-8.8 | 2 | RONDELLE-M12-PLA-8.8 | PLA-8.8 | 2
2 x Bolt assembly | 12 | 100 | SB8.8 Galva | M12*100 | SB8.8_GALVA | 12 | 2 | 14 | ECROU-M12-E-SB8.8 | E-SB8.8 | 2 | RONDELLE-M12-PLA-8.8 | PLA-8.8 | 2
54 x Bolt assembly | 12 | 100 | SB8.8 Galva | M12*100 | SB8.8_GALVA | 12 | 1 | 15 | ECROU-M12-E-SB8.8 | E-SB8.8 | 1 | RONDELLE-M12-PLA-8.8 | PLA-8.8 | 0
23 x Bolt assembly | 12 | 35 | SB8.8 Galva | M12*35 | SB8.8_GALVA | 12 | 2 | 15 | ECROU-M12-E-SB8.8 | E-SB8.8 | 2 | RONDELLE-M12-PLA-8.8 | PLA-8.8 | 0
12 x Bolt assembly | 16 | 40 | SB8.8 Galva | M16*40 | SB8.8_GALVA | 16 | 2 | 19 | ECROU-M16-E-SB8.8 | E-SB8.8 | 2 | RONDELLE-M16-PLA-8.8 | PLA-8.8 | 0
Bolt assembly | 16 | 45 | SB8.8 Galva | M16*45 | SB8.8_GALVA | 16 | 4 | 19 | ECROU-M16-E-SB8.8 | E-SB8.8 | 4 | RONDELLE-M16-PLA-8.8 | PLA-8.8 | 0
12 x Bolt assembly | 20 | 10 | SB8.8 Galva | M20*40 | SB8.8_GALVA | 24 | 1 | 24 | ECROU-M20-E-SB8.8 | E-SB8.8 | 0 | RONDELLE-M20-PLA-8.8 | PLA-8.8 | 0
6 x Bolt assembly | 20 | 12 | SB8.8 Galva | M20*40 | SB8.8_GALVA | 24 | 2 | 24 | ECROU-M20-E-SB8.8 | E-SB8.8 | 0 | RONDELLE-M20-PLA-8.8 | PLA-8.8 | 0
Bolt assembly | 16 | 30 | SB8.8 Galva | M16*30 | SB8.8_GALVA | 16 | 1 | 19 | ECROU-M16-E-SB8.8 | E-SB8.8 | 1 | RONDELLE-M16-PLA-8.8 | PLA-8.8 | 0
4 x Bolt assembly | 12 | 35 | SB8.8 Galva | M12*35 | SB8.8_GALVA | 12 | 2 | 15 | ECROU-M12-E-SB8.8 | E-SB8.8 | 2 | RONDELLE-M12-PLA-8.8 | PLA-8.8 | 2
2 x Bolt assembly | 12 | 100 | SB8.8 Galva | M12*100 | SB8.8_GALVA | 12 | 2 | 15 | ECROU-M12-E-SB8.8 | E-SB8.8 | 2 | RONDELLE-M12-PLA-8.8 | PLA-8.8 | 0
32 x Bolt assembly | 12 | 30 | SB8.8 Galva | M12*30 | SB8.8_GALVA | 12 | 2 | 15 | ECROU-M12-E-SB8.8 | E-SB8.8 | 2 | RONDELLE-M12-PLA-8.8 | PLA-8.8 | 2
26 x Bolt assembly | 10 | 4 | SB8.8 Galva | M10*20 | SB8.8_GALVA | 12 | 2 | 12 | ECROU-M10-E-SB8.8 | E-SB8.8 | 0 | RONDELLE-M10-PLA-8.8 | PLA-8.8 | 0
2 x Bolt assembly | 16 | 100 | SPIT-FIX-II |  | SPIT-FIX-II | 16 | 2 | 19 |  |  | 2 |  |  | 2
2 x Bolt assembly | 16 | 35 | SB8.8 Galva | M16*35 | SB8.8_GALVA | 16 | 2 | 19 | ECROU-M16-E-SB8.8 | E-SB8.8 | 2 | RONDELLE-M16-PLA-8.8 | PLA-8.8 | 2
51 x Bolt assembly | 12 | 30 | SB8.8 Galva | M12*30 | SB8.8_GALVA | 12 | 1 | 15 | ECROU-M12-E-SB8.8 | E-SB8.8 | 1 | RONDELLE-M12-PLA-8.8 | PLA-8.8 | 0
8 x Bolt assembly | 16 | 45 | SB8.8 Galva | M16*45 | SB8.8_GALVA | 16 | 2 | 19 | ECROU-M16-E-SB8.8 | E-SB8.8 | 2 | RONDELLE-M16-PLA-8.8 | PLA-8.8 | 0
Bolt assembly | 12 | 40 | SB8.8 Galva | M12*40 | SB8.8_GALVA | 12 | 1 | 15 | ECROU-M12-E-SB8.8 | E-SB8.8 | 1 | RONDELLE-M12-PLA-8.8 | PLA-8.8 | 0
Bolt assembly | 10 | 20 | SB8.8 Galva | M10*20 | SB8.8_GALVA | 10 | 1 | 13 | ECROU-M10-E-SB8.8 | E-SB8.8 | 1 | RONDELLE-M10-PLA-8.8 | PLA-8.8 | 0

# IfcMember: L45*4.5 (16)
In: Undefined
Description: L45*4.5; Material: STEEL/S235JR
Tekla Commun - Nom: CV; Profil: L45*4.5; Matériau: S235JR; Classe: 1; Phase: 1; Repère: CV0(?); Repère assemblage: CV0(?); Niveau haut: +1.903; Niveau bas: +1.503
Tekla Quantités - Largeur: 45 mm; Hauteur: 45 mm; Surface par tonne: 56.835 m2; Surface: 0 m2; Volume: 0 m3
MemberBaseQuantities - Surface extérieure: 0.1 m2; Surface brute: 0.1 m2; Surface section: 0 m2; Volume net: 0 m3; Volume brut: 0 m3
Name | Tekla Quantités, Longueur (mm) = MemberBaseQuantities, Longueur (mm) | Surface nette (m2) | Poids (kg) | Poids net (kg) | Poids brut (kg) | Inclinaison (rad)
4 x CV | 520.8 | 0.095 | 1.59 | 1.6 | 1.6 | 0.7854
4 x CV | 612.9 | 0.111 | 1.88 | 1.9 | 1.9 | 0.63571
4 x CV | 603.5 | 0.109 | 1.85 | 1.7 | 1.8 | 0.64793
4 x CV | 634.5 | 0.115 | 1.94 | 1.9 | 1.9 | 0.60942

# IfcMember: TUBE-26.9*2 (12)
In: Undefined
Description: TUBE-26.9*2; Material: STEEL/S235JR
Tekla Commun - Profil: TUBE-26.9*2; Matériau: S235JR; Classe: 1; Phase: 1; Repère: 0(?)
Tekla Quantités - Largeur: 26.9 mm; Hauteur: 26.9 mm; Surface: 0 m2; Volume: 0.001 m3
MemberBaseQuantities - Surface extérieure: 0.3 m2; Surface brute: 0 m2; Surface section: 0 m2; Volume net: 0 m3; Volume brut: 0 m3
Name | Nom | Repère assemblage | Niveau haut | Niveau bas | Tekla Quantités, Longueur (mm) = MemberBaseQuantities, Longueur (mm) | Surface nette (m2) | Surface par tonne (m2) | Poids (kg) | Poids net (kg) | Poids brut (kg) | Inclinaison (rad)
RAIL | RAIL | M0(?) | +4.428 | +2.289 | 4429.4 | 0.37 | 68.057 | 5.44 | 5.2 | 5.4 | 0.49785
RAIL | RAIL | 0(?) | +4.428 | +2.289 | 4429.4 | 0.37 | 68.057 | 5.44 | 5.2 | 5.4 | 0.49785
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 0(?) | +4.798 | +2.665 | 4418 | 0.369 | 68.057 | 5.43 | 5.2 | 5.4 | 0.49785
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 0(?) | +5.013 | +2.880 | 4418 | 0.369 | 68.057 | 5.43 | 5.2 | 5.4 | 0.49785
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | M0(?) | +4.798 | +2.665 | 4418 | 0.369 | 68.057 | 5.43 | 5.2 | 5.4 | 0.49785
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | M0(?) | +5.013 | +2.880 | 4418 | 0.369 | 68.057 | 5.43 | 5.2 | 5.4 | 0.49785
RAIL | RAIL | M0(?) | +2.253 | +0.272 | 4111.8 | 0.344 | 68.059 | 5.05 | 4.8 | 5 | 0.4962
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | M0(?) | +2.624 | +0.648 | 4100.4 | 0.343 | 68.059 | 5.05 | 4.8 | 5 | 0.4962
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | M0(?) | +2.839 | +0.863 | 4100.4 | 0.343 | 68.059 | 5.05 | 4.8 | 5 | 0.4962
RAIL | RAIL | 0(?) | +2.253 | +0.272 | 4111.8 | 0.344 | 68.059 | 5.05 | 4.8 | 5 | 0.4962
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 0(?) | +2.624 | +0.648 | 4100.4 | 0.343 | 68.059 | 5.05 | 4.8 | 5 | 0.4962
MONTANT GARDE-CORPS | MONTANT GARDE-CORPS | 0(?) | +2.839 | +0.863 | 4100.4 | 0.343 | 68.059 | 5.05 | 4.8 | 5 | 0.4962

# IfcMember: TUBE-48.3*2 (5)
In: Undefined
Description: TUBE-48.3*2; Material: STEEL/S235JR
Tekla Commun - Profil: TUBE-48.3*2; Matériau: S235JR; Phase: 1; Repère: 0(?)
Tekla Quantités - Hauteur: 48.3 mm; Surface: 0 m2
MemberBaseQuantities - Surface brute: 0 m2; Surface section: 0 m2; Volume net: 0 m3; Volume brut: 0 m3
Name | Nom | Classe | Repère assemblage | Niveau haut | Niveau bas | Tekla Quantités, Longueur (mm) = MemberBaseQuantities, Longueur (mm) | Largeur (mm) | Surface nette (m2) | Surface par tonne (m2) | Volume (m3) | Poids (kg) | Surface extérieure (m2) | Poids net (kg) | Poids brut (kg) | Inclinaison (rad)
COUDE | COUDE | 99 | 0(?) | +5.426 | +5.308 | 111.4 | 2 | 0.017 | 65.893 | 0 | 0.25 | 0 | 0.2 | 0.3 | 0.94895
RAIL | RAIL | 1 | 0(?) | +5.351 | +3.183 | 4452.5 | 48.3 | 0.668 | 65.718 | 0.001 | 10.17 | 0.7 | 9.7 | 10.2 | 0.49785
RAIL | RAIL | 1 | M0(?) | +5.418 | +3.070 | 4827.8 | 48.3 | 0.723 | 65.539 | 0.001 | 11.03 | 0.7 | 10.5 | 11 | 0.49785
RAIL | RAIL | 1 | M0(?) | +3.125 | +1.063 | 4242.1 | 48.3 | 0.635 | 65.519 | 0.001 | 9.69 | 0.7 | 9.2 | 9.7 | 0.4962
RAIL | RAIL | 1 | 0(?) | +3.213 | +1.063 | 4426.9 | 48.3 | 0.664 | 65.718 | 0.001 | 10.11 | 0.7 | 9.7 | 10.2 | 0.4962

# IfcMember: UPE240 (6)
In: Undefined
Description: UPE240; Material: STEEL/S235JR
Tekla Commun - Nom: LIMON; Profil: UPE240; Matériau: S235JR; Classe: 1; Phase: 1; Repère assemblage: LM0(?)
Tekla Quantités - Largeur: 90 mm; Hauteur: 240 mm; Surface par tonne: 26.9 m2; Surface: 0 m2
MemberBaseQuantities - Surface section: 0 m2; Volume net: 0 m3; Volume brut: 0 m3
Name | Repère | Niveau haut | Niveau bas | Tekla Quantités, Longueur (mm) = MemberBaseQuantities, Longueur (mm) | Surface nette (m2) | Volume (m3) | Poids (kg) | Surface extérieure (m2) = Surface brute (m2) | Poids net (kg) | Poids brut (kg) | Inclinaison (rad)
LIMON | LM0(?) | +0.168 | -0.011 | 178.4 | 0.096 | 0.001 | 5.39 | 0.1 | 3.2 | 5.4 | 1.57073
LIMON | LM0(?) | +0.168 | -0.011 | 178.4 | 0.096 | 0.001 | 5.39 | 0.1 | 3.2 | 5.4 | 1.57072
LIMON | LM0(?) | +4.360 | +1.945 | 4615.6 | 3.77 | 0.018 | 139.5 | 3.8 | 134.3 | 139.5 | 0.49785
LIMON | 0(?) | +4.360 | +1.945 | 4615.6 | 3.77 | 0.018 | 139.5 | 3.8 | 134.3 | 139.5 | 0.49785
2 x LIMON | 0(?) | +2.185 | +0.025 | 4236.9 | 3.424 | 0.016 | 128.05 | 3.4 | 121.9 | 128 | 0.4962

# IfcPlate: PL10*100 (2)
In: Undefined
Description: PL10*100; Material: STEEL/S235JR
Tekla Commun - Profil: PL10*100; Matériau: S235JR; Classe: 99; Phase: 1; Repère: E0(?); Repère assemblage: E0(?); Niveau haut: -0.011; Niveau bas: -0.021
Tekla Quantités - Longueur: 250 mm; Largeur: 10 mm; Hauteur: 100 mm; Surface nette: 0.057 m2; Surface par tonne: 29.045 m2; Surface: 0.025 m2; Volume: 0 m3; Poids: 1.96 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 100 mm; Surface: 0.1 m2; Surface brute: 0.1 m2; Surface section: 0 m2

# IfcPlate: PL10*110 (22)
In: Undefined
Description: PL10*110; Material: STEEL/S235JR
Tekla Commun - Nom: TOLE; Profil: PL10*110; Matériau: S235JR; Classe: 99; Phase: 1; Repère: 0(?)
Tekla Quantités - Largeur: 10 mm; Hauteur: 110 mm; Volume: 0 m3
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 110 mm; Surface: 0 m2; Surface brute: 0 m2; Surface section: 0 m2
Name | Repère assemblage | Niveau haut | Niveau bas | Longueur (mm) | Surface nette (m2) | Surface par tonne (m2) | Surface (m2) | Poids (kg)
3 x TOLE | T0(?) | +4.340 | +4.280 | 60 | 0.017 | 32.04 | 0.001 | 0.52
3 x TOLE | T0(?) | +4.355 | +4.285 | 70 | 0.019 | 31.434 | 0.001 | 0.6
2 x TOLE | P0(?) | +4.118 | +4.108 | 86 | 0.023 | 30.756 | 0.009 | 0.74
4 x TOLE | P0(?) | +1.913 | +1.903 | 86 | 0.023 | 30.756 | 0.009 | 0.74
5 x TOLE | T0(?) | +2.150 | +2.080 | 70 | 0.019 | 31.434 | 0.001 | 0.6
5 x TOLE | T0(?) | +2.135 | +2.075 | 60 | 0.017 | 32.04 | 0.001 | 0.52

# IfcPlate: PL10*140 (6)
In: Undefined
Description: PL10*140; Material: STEEL/S235JR
Tekla Commun - Nom: BRIDE; Profil: PL10*140; Matériau: S235JR; Classe: 99; Phase: 1; Repère: 0(?); Repère assemblage: P0(?)
Tekla Quantités - Longueur: 139.7 mm; Largeur: 10 mm; Hauteur: 139.7 mm; Surface nette: 0.035 m2; Surface par tonne: 29.157 m2; Surface: 0.015 m2; Volume: 0 m3; Poids: 1.19 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 139.7 mm; Surface: 0 m2; Surface brute: 0 m2; Surface section: 0 m2
Name | Niveau haut | Niveau bas
4 x BRIDE | +1.862 | +1.852
2 x BRIDE | +4.067 | +4.057

# IfcPlate: PL10*200 (2)
In: Undefined
Description: PL10*200; Material: STEEL/S235JR
Tekla Commun - Nom: TOLE; Profil: PL10*200; Matériau: S235JR; Classe: 99; Phase: 1; Niveau haut: +4.355; Niveau bas: +4.125
Tekla Quantités - Longueur: 230 mm; Largeur: 10 mm; Hauteur: 200 mm; Surface nette: 0.101 m2; Surface par tonne: 27.859 m2; Surface: 0.002 m2; Volume: 0 m3; Poids: 3.61 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 200 mm; Surface: 0.1 m2; Surface brute: 0.1 m2; Surface section: 0 m2
Name | Repère | Repère assemblage
TOLE | 0(?) | T0(?)
TOLE | E0(?) | E0(?)

# IfcPlate: PL10*50 (53)
In: Undefined
Description: PL10*50; Material: STEEL/S235JR
Tekla Commun - Profil: PL10*50; Matériau: S235JR; Classe: 99; Phase: 1; Repère: 0(?)
Tekla Quantités - Largeur: 10 mm; Hauteur: 50 mm; Volume: 0 m3
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 50 mm; Surface: 0 m2; Surface brute: 0 m2; Surface section: 0 m2
Name | Repère assemblage | Niveau haut | Niveau bas | Longueur (mm) | Surface nette (m2) | Surface par tonne (m2) | Surface (m2) | Poids (kg)
2 x Unnamed | MA0(?) | +2.338 | +2.288 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | MA0(?) | +2.496 | +2.446 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | MA0(?) | +2.811 | +2.761 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | MA0(?) | +2.969 | +2.919 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | MA0(?) | +3.126 | +3.076 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | MA0(?) | +3.284 | +3.234 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | MA0(?) | +3.442 | +3.392 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | MA0(?) | +4.072 | +4.022 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | MA0(?) | +3.915 | +3.865 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | MA0(?) | +3.757 | +3.707 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | MA0(?) | +3.599 | +3.549 | 340 | 0.038 | 31.588 | 0.003 | 1.21
Unnamed | MA0(?) | +4.230 | +4.180 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | MA0(?) | +2.654 | +2.604 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | ATT0(?) | +2.024 | +1.973 | 309.9 | 0.038 | 31.365 | 0.003 | 1.21
2 x Unnamed | ATT0(?) | +1.866 | +1.816 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | ATT0(?) | +1.709 | +1.659 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | ATT0(?) | +1.551 | +1.501 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | ATT0(?) | +1.394 | +1.344 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | ATT0(?) | +1.236 | +1.186 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | ATT0(?) | +1.079 | +1.029 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | ATT0(?) | +0.921 | +0.871 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | ATT0(?) | +0.764 | +0.714 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | ATT0(?) | +0.606 | +0.556 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | ATT0(?) | +0.449 | +0.399 | 340 | 0.038 | 31.588 | 0.003 | 1.21
2 x Unnamed | MA0(?) | +2.181 | +2.131 | 400.1 | 0.046 | 31.423 | 0.004 | 1.45
2 x Unnamed | ATT0(?) | +0.291 | +0.241 | 340 | 0.038 | 31.588 | 0.003 | 1.21
Unnamed | MA0(?) | +0.133 | +0.083 | 340 | 0.038 | 31.588 | 0.003 | 1.21
Unnamed | MA0(?) | +0.134 | +0.084 | 340 | 0.038 | 31.588 | 0.003 | 1.21

# IfcPlate: PL10*56 (16)
In: Undefined
Description: PL10*56; Material: STEEL/S235JR
Tekla Commun - Profil: PL10*56; Matériau: S235JR; Classe: 1; Phase: 1; Repère: 0(?)
Tekla Quantités - Longueur: 73.2 mm; Largeur: 10 mm; Hauteur: 56.4 mm; Surface nette: 0.011 m2; Surface par tonne: 33.279 m2; Surface: 0 m2; Volume: 0 m3; Poids: 0.31 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 56.4 mm; Surface: 0 m2; Surface brute: 0 m2; Surface section: 0 m2
Name | Repère assemblage | Niveau haut | Niveau bas
2 x Unnamed | T0(?) | +2.355 | +2.281
2 x Unnamed | P0(?) | +2.355 | +2.281
2 x Unnamed | T0(?) | +1.490 | +1.416
10 x Unnamed | P0(?) | +1.490 | +1.416

# IfcPlate: PL10*60 (40)
In: Undefined
Description: PL10*60; Material: STEEL/S235JR
Tekla Commun - Nom: MONTANT GARDE-CORPS; Profil: PL10*60; Matériau: S235JR; Classe: 1; Phase: 1
Tekla Quantités - Largeur: 10 mm; Hauteur: 60 mm; Surface: 0 m2; Volume: 0.001 m3
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 60 mm; Surface: 0.1 m2; Surface section: 0 m2
Name | Repère | Repère assemblage | Niveau haut | Niveau bas | Longueur (mm) | Surface nette (m2) | Surface par tonne (m2) | Poids (kg) | Surface brute (m2)
MONTANT GARDE-CORPS | M0(?) | M0(?) | +3.075 | +2.193 | 882.3 | 0.121 | 30.072 | 4.02 | 0.2
MONTANT GARDE-CORPS | M0(?) | M0(?) | +3.132 | +2.193 | 938.8 | 0.129 | 30.05 | 4.29 | 0.2
2 x MONTANT GARDE-CORPS | 0(?) | M0(?) | +3.174 | +2.163 | 1010.7 | 0.14 | 30.002 | 4.67 | 0.1
MONTANT GARDE-CORPS | 0(?) | M0(?) | +5.248 | +4.368 | 879.7 | 0.12 | 30.093 | 3.98 | 0.1
5 x MONTANT GARDE-CORPS | 0(?) | M0(?) | +5.379 | +4.368 | 1010.7 | 0.14 | 30.002 | 4.67 | 0.1
MONTANT GARDE-CORPS | 0(?) | M0(?) | +5.249 | +4.368 | 880.7 | 0.122 | 30.044 | 4.05 | 0.1
MONTANT GARDE-CORPS | 0(?) | 0(?) | +5.379 | +4.368 | 1011.4 | 0.14 | 30.002 | 4.67 | 0.1
MONTANT GARDE-CORPS | 0(?) | 0(?) | +5.379 | +4.368 | 1010.9 | 0.14 | 30.002 | 4.67 | 0.1
7 x MONTANT GARDE-CORPS | 0(?) | 0(?) | +3.174 | +2.163 | 1010.7 | 0.14 | 30.002 | 4.67 | 0.1
MONTANT GARDE-CORPS | 0(?) | M0(?) | +5.195 | +4.334 | 860.8 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | M0(?) | +4.666 | +3.805 | 860.8 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | M0(?) | +4.137 | +3.276 | 860.8 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | M0(?) | +3.608 | +2.747 | 860.8 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | M0(?) | +3.079 | +2.219 | 860.8 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | 0(?) | +5.195 | +4.334 | 860.8 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | 0(?) | +4.666 | +3.805 | 860.8 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | 0(?) | +4.137 | +3.276 | 860.8 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | 0(?) | +3.608 | +2.747 | 860.8 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | 0(?) | +3.174 | +2.219 | 955.1 | 0.132 | 30.038 | 4.39 | 0.1
MONTANT GARDE-CORPS | 0(?) | M0(?) | +3.020 | +2.159 | 860.9 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | M0(?) | +2.530 | +1.669 | 860.9 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | M0(?) | +2.041 | +1.180 | 860.9 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | M0(?) | +1.552 | +0.691 | 860.9 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | M0(?) | +1.062 | +0.201 | 860.9 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | 0(?) | +3.020 | +2.159 | 860.9 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | 0(?) | +2.530 | +1.669 | 860.9 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | 0(?) | +2.041 | +1.180 | 860.9 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | 0(?) | +1.552 | +0.691 | 860.9 | 0.12 | 30.078 | 3.94 | 0.1
MONTANT GARDE-CORPS | 0(?) | 0(?) | +1.062 | +0.201 | 860.9 | 0.12 | 30.078 | 3.94 | 0.1

# IfcPlate: PL10*76 (8)
In: Undefined
Description: PL10*76; Material: STEEL/S235JR
Tekla Commun - Nom: BRIDE; Profil: PL10*76; Matériau: S235JR; Classe: 99; Phase: 1; Repère: 0(?); Repère assemblage: T0(?)
Tekla Quantités - Longueur: 76.1 mm; Largeur: 10 mm; Hauteur: 76.1 mm; Surface nette: 0.011 m2; Surface par tonne: 32.194 m2; Surface: 0 m2; Volume: 0 m3; Poids: 0.36 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 76.1 mm; Surface: 0 m2; Surface brute: 0 m2; Surface section: 0 m2
Name | Niveau haut | Niveau bas
2 x BRIDE | +2.356 | +2.280
6 x BRIDE | +1.491 | +1.415

# IfcPlate: PL10*80 (12)
In: Undefined
Description: PL10*80; Material: STEEL/S235JR
Tekla Commun - Nom: PLAT; Profil: PL10*80; Matériau: S235JR; Classe: 1; Phase: 1; Repère: 0(?); Repère assemblage: B0(?)
Tekla Quantités - Longueur: 80 mm; Largeur: 10 mm; Hauteur: 80 mm; Surface nette: 0.016 m2; Surface par tonne: 31.847 m2; Surface: 0.006 m2; Volume: 0 m3; Poids: 0.5 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 80 mm; Surface: 0 m2; Surface brute: 0 m2; Surface section: 0 m2
Name | Niveau haut | Niveau bas
8 x PLAT | -0.309 | -0.319
4 x PLAT | -0.308 | -0.318

# IfcPlate: PL10*90 (21)
In: Undefined
Description: PL10*90; Material: STEEL/S235JR
Tekla Commun - Profil: PL10*90; Matériau: S235JR; Classe: 99; Phase: 1; Repère: 0(?)
Tekla Quantités - Longueur: 230 mm; Largeur: 10 mm; Hauteur: 90 mm; Surface nette: 0.048 m2; Surface par tonne: 29.416 m2; Surface: 0.001 m2; Volume: 0 m3; Poids: 1.62 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 90 mm; Surface: 0 m2; Surface brute: 0 m2; Surface section: 0 m2
Name | Nom | Repère assemblage | Niveau haut | Niveau bas
6 x TOLE | TOLE | T0(?) | +4.355 | +4.125
TOLE | TOLE | 0(?) | +2.180 | +1.950
3 x TOLE | TOLE | LM0(?) | +2.180 | +1.950
PLATINE | PLATINE | T0(?) | +4.355 | +4.125
4 x PLATINE | PLATINE | T0(?) | +2.150 | +1.920
6 x TOLE | TOLE | T0(?) | +2.150 | +1.920

# IfcPlate: PL12*270 (6)
In: Undefined
Description: PL12*270; Material: STEEL/S235JR
Tekla Commun - Nom: PLAT; Profil: PL12*270; Matériau: S235JR; Classe: 99; Phase: 1; Repère: 0(?); Repère assemblage: P0(?)
Tekla Quantités - Longueur: 179.7 mm; Largeur: 12 mm; Hauteur: 270 mm; Surface nette: 0.108 m2; Surface par tonne: 23.593 m2; Surface: 0.049 m2; Volume: 0.001 m3; Poids: 4.57 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 270 mm; Surface: 0.1 m2; Surface brute: 0.1 m2; Surface section: 0 m2
Name | Niveau haut | Niveau bas
4 x PLAT | -0.009 | -0.021
2 x PLAT | -0.008 | -0.020

# IfcPlate: PL30*1000, CAILLEBOTIS
In: Undefined
Description: PL30*1000; Material: STEEL/S235JR
Tekla Commun - Nom: CAILLEBOTIS; Profil: PL30*1000; Matériau: S235JR; Classe: 99; Phase: 1; Repère: G0(?); Repère assemblage: G0(?); Niveau haut: +4.390; Niveau bas: +4.360
Tekla Quantités - Longueur: 1550 mm; Largeur: 30 mm; Hauteur: 1000 mm; Surface nette: 3.253 m2; Surface par tonne: 8.912 m2; Surface: 1.55 m2; Volume: 0.046 m3; Poids: 365.02 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 1000 mm; Surface: 3.3 m2; Surface brute: 1.6 m2; Surface section: 0 m2

# IfcPlate: PL30*1101, CAILLEBOTIS
In: Undefined
Description: PL30*1101; Material: STEEL/S235JR
Tekla Commun - Nom: CAILLEBOTIS; Profil: PL30*1101; Matériau: S235JR; Classe: 99; Phase: 1; Repère: G0(?); Repère assemblage: G0(?); Niveau haut: +4.390; Niveau bas: +4.360
Tekla Quantités - Longueur: 1550 mm; Largeur: 30 mm; Hauteur: 1101.2 mm; Surface nette: 3.573 m2; Surface par tonne: 8.888 m2; Surface: 1.707 m2; Volume: 0.051 m3; Poids: 401.97 kg
PlateBaseQuantities - Volume net: 0.1 m3; Volume brut: 0.1 m3; Largeur: 1101.2 mm; Surface: 3.6 m2; Surface brute: 1.7 m2; Surface section: 0 m2

# IfcPlate: PL30*868 (4)
In: Undefined
Description: PL30*868; Material: STEEL/S235JR
Tekla Commun - Nom: CAILLEBOTIS; Profil: PL30*868; Matériau: S235JR; Classe: 99; Phase: 1; Repère: G0(?); Repère assemblage: G0(?); Niveau haut: +2.185; Niveau bas: +2.155
Tekla Quantités - Longueur: 1550 mm; Largeur: 30 mm; Hauteur: 867.5 mm; Surface nette: 2.834 m2; Surface par tonne: 8.951 m2; Surface: 1.345 m2; Volume: 0.04 m3; Poids: 316.66 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 867.5 mm; Surface: 2.8 m2; Surface brute: 1.3 m2; Surface section: 0 m2

# IfcPlate: PL4*38, Unnamed
In: Undefined
Description: PL4*38; Material: STEEL/S235JR
Tekla Commun - Profil: PL4*38; Matériau: S235JR; Classe: 1; Phase: 1; Repère: 0(?); Repère assemblage: ATT0(?); Niveau haut: +0.089; Niveau bas: -0.014
Tekla Quantités - Longueur: 102.5 mm; Largeur: 4 mm; Hauteur: 37.8 mm; Surface nette: 0.005 m2; Surface par tonne: 80.121 m2; Surface: 0 m2; Volume: 0 m3; Poids: 0.06 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 37.8 mm; Surface: 0 m2; Surface brute: 0 m2; Surface section: 0 m2

# IfcPlate: PL6*55, Unnamed
In: Undefined
Description: PL6*55; Material: STEEL/S235JR
Tekla Commun - Profil: PL6*55; Matériau: S235JR; Classe: 1; Phase: 1; Repère: 0(?); Repère assemblage: ATT0(?); Niveau haut: -0.014; Niveau bas: -0.020
Tekla Quantités - Longueur: 60 mm; Largeur: 6 mm; Hauteur: 55 mm; Surface nette: 0.008 m2; Surface par tonne: 51.341 m2; Surface: 0.003 m2; Volume: 0 m3; Poids: 0.16 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 55 mm; Surface: 0 m2; Surface brute: 0 m2; Surface section: 0 m2

# IfcPlate: PL8*102 (4)
In: Undefined
Description: PL8*102; Material: STEEL/S235JR
Tekla Commun - Nom: GOUSSET; Profil: PL8*102; Matériau: S235JR; Classe: 99; Phase: 1; Repère: 0(?); Repère assemblage: T0(?); Niveau haut: +1.915; Niveau bas: +1.809
Tekla Quantités - Longueur: 185.4 mm; Largeur: 8 mm; Hauteur: 101.8 mm; Surface nette: 0.024 m2; Surface par tonne: 37.737 m2; Surface: 0.001 m2; Volume: 0 m3; Poids: 0.65 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 101.8 mm; Surface: 0 m2; Surface brute: 0 m2; Surface section: 0 m2

# IfcPlate: PL8*103 (4)
In: Undefined
Description: PL8*103; Material: STEEL/S235JR
Tekla Commun - Nom: GOUSSET; Profil: PL8*103; Matériau: S235JR; Classe: 99; Phase: 1; Repère: 0(?); Repère assemblage: T0(?); Niveau haut: +1.915; Niveau bas: +1.800
Tekla Quantités - Longueur: 162 mm; Largeur: 8 mm; Hauteur: 103.5 mm; Surface nette: 0.023 m2; Surface par tonne: 37.575 m2; Surface: 0.001 m2; Volume: 0 m3; Poids: 0.61 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 103.5 mm; Surface: 0 m2; Surface brute: 0 m2; Surface section: 0 m2

# IfcPlate: PL8*106 (2)
In: Undefined
Description: PL8*106; Material: STEEL/S235JR
Tekla Commun - Nom: GOUSSET; Profil: PL8*106; Matériau: S235JR; Classe: 99; Phase: 1; Repère: 0(?); Repère assemblage: T0(?); Niveau haut: +1.597; Niveau bas: +1.491
Tekla Quantités - Longueur: 276.4 mm; Largeur: 8 mm; Hauteur: 106.1 mm; Surface nette: 0.063 m2; Surface par tonne: 35.122 m2; Surface: 0.002 m2; Volume: 0 m3; Poids: 1.78 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 106.1 mm; Surface: 0.1 m2; Surface brute: 0 m2; Surface section: 0 m2

# IfcPlate: PL8*108 (4)
In: Undefined
Description: PL8*108; Material: STEEL/S235JR
Tekla Commun - Nom: GOUSSET; Profil: PL8*108; Matériau: S235JR; Classe: 99; Phase: 1; Repère: 0(?); Repère assemblage: T0(?); Niveau haut: +1.915; Niveau bas: +1.807
Tekla Quantités - Largeur: 8 mm; Surface: 0.002 m2; Volume: 0 m3
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Surface: 0.1 m2; Surface brute: 0 m2; Surface section: 0 m2
Name | Longueur (mm) | Hauteur (mm) = Largeur (mm) | Surface nette (m2) | Surface par tonne (m2) | Poids (kg)
2 x GOUSSET | 269.2 | 107.6 | 0.062 | 35.113 | 1.76
2 x GOUSSET | 265.7 | 108.2 | 0.061 | 35.111 | 1.75

# IfcPlate: PL8*109 (6)
In: Undefined
Description: PL8*109; Material: STEEL/S235JR
Tekla Commun - Nom: GOUSSET; Profil: PL8*109; Matériau: S235JR; Classe: 99; Phase: 1; Repère: 0(?)
Tekla Quantités - Largeur: 8 mm; Volume: 0 m3
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Surface brute: 0 m2; Surface section: 0 m2
Name | Repère assemblage | Niveau haut | Niveau bas | Longueur (mm) | Hauteur (mm) = Largeur (mm) | Surface nette (m2) | Surface par tonne (m2) | Tekla Quantités, Surface (m2) | Poids (kg) | PlateBaseQuantities, Surface (m2)
GOUSSET | P0(?) | +2.566 | +2.405 | 172.3 | 108.7 | 0.025 | 37.353 | 0.001 | 0.67 | 0
GOUSSET | P0(?) | +4.005 | +3.844 | 172.3 | 108.7 | 0.025 | 37.353 | 0 | 0.67 | 0
GOUSSET | P0(?) | +4.042 | +3.881 | 172.3 | 108.7 | 0.025 | 37.353 | 0 | 0.67 | 0
GOUSSET | P0(?) | +2.529 | +2.368 | 172.3 | 108.7 | 0.025 | 37.353 | 0.001 | 0.67 | 0
2 x GOUSSET | T0(?) | +1.600 | +1.491 | 266.9 | 108.9 | 0.062 | 35.1 | 0 | 1.76 | 0.1

# IfcPlate: PL8*115 (2)
In: Undefined
Description: PL8*115; Material: STEEL/S235JR
Tekla Commun - Nom: GOUSSET; Profil: PL8*115; Matériau: S235JR; Classe: 99; Phase: 1; Repère: 0(?); Repère assemblage: T0(?); Niveau haut: +1.605; Niveau bas: +1.491
Tekla Quantités - Longueur: 248.7 mm; Largeur: 8 mm; Hauteur: 114.5 mm; Surface nette: 0.059 m2; Surface par tonne: 35.113 m2; Surface: 0 m2; Volume: 0 m3; Poids: 1.67 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 114.5 mm; Surface: 0.1 m2; Surface brute: 0 m2; Surface section: 0 m2

# IfcPlate: PL8*120 (40)
In: Undefined
Description: PL8*120; Material: STEEL/S235JR
Tekla Commun - Profil: PL8*120; Matériau: S235JR; Classe: 99; Phase: 1; Repère: 0(?)
Tekla Quantités - Largeur: 8 mm; Volume: 0 m3
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Surface brute: 0 m2; Surface section: 0 m2
Name | Nom | Repère assemblage | Niveau haut | Niveau bas | Longueur (mm) | Hauteur (mm) = Largeur (mm) | Surface nette (m2) | Surface par tonne (m2) | Tekla Quantités, Surface (m2) | Poids (kg) | PlateBaseQuantities, Surface (m2)
2 x PLATINE | PLATINE | M0(?) | +2.163 | +2.155 | 60 | 120 | 0.017 | 38.217 | 0.007 | 0.45 | 0
7 x PLATINE | PLATINE | M0(?) | +4.368 | +4.360 | 60 | 120 | 0.017 | 38.217 | 0.007 | 0.45 | 0
2 x PLATINE | PLATINE | 0(?) | +4.368 | +4.360 | 60 | 120 | 0.017 | 38.217 | 0.007 | 0.45 | 0
7 x PLATINE | PLATINE | 0(?) | +2.163 | +2.155 | 60 | 120 | 0.017 | 38.217 | 0.007 | 0.45 | 0
PLATINE | PLATINE | M0(?) | +4.365 | +4.301 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | M0(?) | +3.836 | +3.772 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | M0(?) | +3.308 | +3.243 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | M0(?) | +2.779 | +2.714 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | M0(?) | +2.250 | +2.186 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | 0(?) | +4.365 | +4.301 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | 0(?) | +3.836 | +3.772 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | 0(?) | +3.308 | +3.243 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | 0(?) | +2.779 | +2.714 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | 0(?) | +2.250 | +2.186 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | M0(?) | +2.190 | +2.126 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | M0(?) | +1.701 | +1.637 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | M0(?) | +1.211 | +1.147 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | M0(?) | +0.722 | +0.658 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | M0(?) | +0.233 | +0.168 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | 0(?) | +2.190 | +2.126 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | 0(?) | +1.701 | +1.637 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | 0(?) | +1.211 | +1.147 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | 0(?) | +0.722 | +0.658 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
PLATINE | PLATINE | 0(?) | +0.233 | +0.168 | 60 | 120 | 0.017 | 38.217 | 0 | 0.45 | 0
2 x GOUSSET | GOUSSET | T0(?) | +1.611 | +1.491 | 246.9 | 120.5 | 0.061 | 35.007 | 0 | 1.74 | 0.1

# IfcPlate: PL8*200, PLATINE
In: Undefined
Description: PL8*200; Material: STEEL/S235JR
Tekla Commun - Nom: PLATINE; Profil: PL8*200; Matériau: S235JR; Classe: 99; Phase: 1; Repère: E0(?); Repère assemblage: E0(?); Niveau haut: +2.193; Niveau bas: +2.185
Tekla Quantités - Longueur: 60 mm; Largeur: 8 mm; Hauteur: 186.7 mm; Surface nette: 0.026 m2; Surface par tonne: 37.458 m2; Surface: 0.011 m2; Volume: 0 m3; Poids: 0.7 kg
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 186.7 mm; Surface: 0 m2; Surface brute: 0 m2; Surface section: 0 m2

# IfcPlate: PLAT50*5 (52)
In: Undefined
Description: PLAT50*5; Material: STEEL/S235JR
Tekla Commun - Profil: PLAT50*5; Matériau: S235JR; Classe: 1; Phase: 1
Tekla Quantités - Largeur: 5 mm; Hauteur: 50 mm; Surface: 0 m2; Volume: 0 m3
PlateBaseQuantities - Volume net: 0 m3; Volume brut: 0 m3; Largeur: 50 mm; Surface: 0 m2; Surface brute: 0 m2; Surface section: 0 m2
Name | Repère | Repère assemblage | Niveau haut | Niveau bas | Longueur (mm) | Surface nette (m2) | Surface par tonne (m2) | Poids (kg)
Unnamed | 0(?) | MA0(?) | +4.230 | +4.180 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | ATT0(?) | ATT0(?) | +4.223 | +4.101 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | MA0(?) | +4.072 | +4.022 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | ATT0(?) | ATT0(?) | +4.065 | +3.943 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | MA0(?) | +3.915 | +3.865 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | ATT0(?) | ATT0(?) | +3.908 | +3.786 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | MA0(?) | +3.757 | +3.707 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | ATT0(?) | ATT0(?) | +3.750 | +3.628 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | MA0(?) | +3.599 | +3.549 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | ATT0(?) | ATT0(?) | +3.592 | +3.470 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | MA0(?) | +3.442 | +3.392 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | ATT0(?) | ATT0(?) | +3.435 | +3.313 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | MA0(?) | +3.284 | +3.234 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | ATT0(?) | ATT0(?) | +3.277 | +3.155 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | MA0(?) | +3.126 | +3.076 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | ATT0(?) | ATT0(?) | +3.119 | +2.997 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | MA0(?) | +2.969 | +2.919 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | ATT0(?) | ATT0(?) | +2.962 | +2.840 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | MA0(?) | +2.811 | +2.761 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | ATT0(?) | ATT0(?) | +2.804 | +2.682 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | MA0(?) | +2.654 | +2.604 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | ATT0(?) | ATT0(?) | +2.647 | +2.524 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | MA0(?) | +2.496 | +2.446 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | ATT0(?) | ATT0(?) | +2.489 | +2.367 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | MA0(?) | +2.338 | +2.288 | 50 | 0.006 | 61.146 | 0.1
Unnamed | 0(?) | ATT0(?) | +2.024 | +1.974 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | 0(?) | ATT0(?) | +2.017 | +1.894 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | ATT0(?) | +1.866 | +1.816 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | 0(?) | ATT0(?) | +1.859 | +1.737 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | ATT0(?) | +1.709 | +1.659 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | 0(?) | ATT0(?) | +1.702 | +1.579 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | ATT0(?) | +1.551 | +1.501 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | 0(?) | ATT0(?) | +1.544 | +1.422 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | ATT0(?) | +1.394 | +1.344 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | 0(?) | ATT0(?) | +1.387 | +1.264 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | ATT0(?) | +1.236 | +1.186 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | 0(?) | ATT0(?) | +1.229 | +1.107 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | ATT0(?) | +1.079 | +1.029 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | 0(?) | ATT0(?) | +1.072 | +0.949 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | ATT0(?) | +0.921 | +0.871 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | 0(?) | ATT0(?) | +0.914 | +0.792 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | ATT0(?) | +0.764 | +0.714 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | 0(?) | ATT0(?) | +0.757 | +0.634 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | ATT0(?) | +0.606 | +0.556 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | 0(?) | ATT0(?) | +0.599 | +0.477 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | ATT0(?) | +0.449 | +0.399 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | 0(?) | ATT0(?) | +0.442 | +0.319 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
ATTACHE MARCHE | ATT0(?) | ATT0(?) | +2.331 | +2.209 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
Unnamed | 0(?) | MA0(?) | +0.134 | +0.084 | 50 | 0.006 | 61.146 | 0.1
Unnamed | 0(?) | ATT0(?) | +0.291 | +0.241 | 50 | 0.006 | 61.146 | 0.1
ATTACHE MARCHE | 0(?) | ATT0(?) | +0.127 | -0.014 | 140.4 | 0.016 | 57.866 | 0.28 | Tekla Commun - Nom: ATTACHE MARCHE
ATTACHE MARCHE | 0(?) | ATT0(?) | +0.284 | +0.162 | 122 | 0.014 | 58.139 | 0.24 | Tekla Commun - Nom: ATTACHE MARCHE
